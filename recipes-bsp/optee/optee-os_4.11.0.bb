require optee-os.inc

DEPENDS += "dtc-native"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV = "86660925433a8d4d1b19cfa5fe940081d77b34b4"
