PACKAGECONFIG:remove:dh-stm32mp1-dhsom = "etnaviv"
