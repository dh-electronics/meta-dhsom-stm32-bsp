IMAGE_INSTALL += " v4l-utils yavta libgpiod libiio "
