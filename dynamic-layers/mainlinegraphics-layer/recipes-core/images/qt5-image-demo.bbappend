IMAGE_INSTALL_append_dh-stm32mp1-dhcom-pdk2 = " vk-gl-cts "
