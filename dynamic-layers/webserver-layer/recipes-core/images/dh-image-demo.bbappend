IMAGE_INSTALL_append_dh-stm32mp1-dhcom-pdk2 = " nginx "
IMAGE_INSTALL_append_dh-stm32mp1-dhcor-avenger96 = " nginx "
