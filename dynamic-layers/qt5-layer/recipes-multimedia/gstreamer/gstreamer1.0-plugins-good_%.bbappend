PACKAGECONFIG_append_dh-stm32mp1-dhcom-pdk2 = " qt5 "
