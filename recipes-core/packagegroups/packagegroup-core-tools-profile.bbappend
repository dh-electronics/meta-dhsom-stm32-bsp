LTTNGTOOLS:remove:dh-stm32mp-dhsom = "lttng-modules"
LTTNGMODULES:dh-stm32mp-dhsom = ""
